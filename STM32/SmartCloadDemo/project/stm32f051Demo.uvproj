# Keil uVision project stm32f051Demo.uvproj, settings and files
target stm32F051Demo (ARM-ADS)
  device: STM32F051K8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: stm32f051Demo +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\lib\inc;..\driver\Led;..\system;..\driver\Systick;..\driver\Usart;..\driver\Key;..\driver\Timer;..\Gizwits;..\Utils;..\driver\DHT11;..\driver\Lcd
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group system
    ./: startup_stm32f051.s
    ../system/: system_stm32f0xx.c stm32f0xx_it.c
  group user
    ../user/: main.c
  group lib
    ../lib/src/: stm32f0xx_rcc.c stm32f0xx_gpio.c stm32f0xx_usart.c stm32f0xx_exti.c stm32f0xx_misc.c stm32f0xx_syscfg.c stm32f0xx_tim.c
  group driver
    ../driver/Led/: Led.c
    ../driver/Systick/: systick.c
    ../driver/Usart/: uart.c
    ../driver/Key/: key.c
    ../driver/Timer/: time.c
    ../driver/DHT11/: DHT11.c
    ../driver/Lcd/: lcd.c
  group include
    ../driver/Led/: Led.h
    ../driver/Systick/: SysTick.h
    ../driver/Usart/: uart.h
    ../driver/Key/: key.h
    ../driver/Timer/: time.h
    ../Gizwits/: gizwits_product.h gizwits_protocol.h
    ../Utils/: common.h dataPointTools.h ringBuffer.h
    ../driver/DHT11/: DHT11.h
    ../driver/Lcd/: lcd.h font_lcd.h
  group gizwits
    ../Gizwits/: gizwits_product.c gizwits_protocol.c
  group utils
    ../Utils/: common.c dataPointTools.c ringbuffer.c
