# Keil uVision project stm1809Demo.uvprojx, settings and files
target stm1809Demo (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm1809Demo
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\FWlib\inc;..\hardware\RCC;..\hardware\SysTick;..\hardware\USART;..\system;F:\app\MDK5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../user/: main.c
  group hardware
    ../hardware/RCC/: sys_rcc.c
    ../hardware/SysTick/: SysTick.c
    ../hardware/USART/: usart_driver.c
    ../hardware/MyGpio/: mygpio.c
    ../hardware/MyKey/: mykey.c
    ../hardware/MyTimer/: mytimer.c
    ../hardware/MyBLE/: myble.c
  group system
    ../system/: stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c
